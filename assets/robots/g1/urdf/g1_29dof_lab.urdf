Commit message: amo first train and  eval,upload logs

File: assets/robots/g1/urdf/g1_29dof_lab.urdf (robot description, URDF)
Before this commit: robot g1_29dof, 44 links, 43 joints
Links:
- link d455_link: geometry visual box size=0.001 0.001 0.001
